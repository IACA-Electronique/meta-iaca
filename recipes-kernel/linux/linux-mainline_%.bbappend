FILESEXTRAPATHS:prepend := "${THISDIR}/files/bananapi:"

SRC_URI += " \
    file://overlay.cfg \
"