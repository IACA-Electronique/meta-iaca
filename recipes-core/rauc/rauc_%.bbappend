FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# See layers/meta-rauc/recipes-core/rauc/rauc-target.inc